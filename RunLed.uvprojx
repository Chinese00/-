# Keil uVision project RunLed.uvprojx, settings and files
target RunLed (ARM-ADS)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00080000) IRAM(0x20000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: RunLed +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: .\USER;.\HEADWORD;.\HEADWORD\Motor;.\HEADWORD\Key;.\HEADWORD\Beep;.\HEADWORD\Led;.\CORE;.\STM32F103\inc;.\STM32F103\src;.\SYSTEM\delay;.\SYSTEM\sys;.\SYSTEM\usart
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group USER
    ./USER/: stm32f10x_it.c system_stm32f10x.c
  group CORE
    ./CORE/: core_cm3.h core_cm3.c startup_stm32f10x_hd.s
  group FWLIB
    ./STM32F103/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group SYSTEM
    ./SYSTEM/delay/: delay.c
    ./SYSTEM/sys/: sys.c
    ./SYSTEM/usart/: usart.c
  group HEADWORD
    ./HEADWORD/: main.c
    ./HEADWORD/Motor/: 24cxx.c CapMode.c encoder.c lcd.c myiic.c pid.c time.c
    ./HEADWORD/Key/: Key.c
    ./HEADWORD/Led/: led.c
